## Kconfig
```kconfig
config RTL8822CU
	tristate "Realtek 8822C USB WiFi"
	help
	  Help message of RTL8822CU
```
